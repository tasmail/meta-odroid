FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += " file://0001-add-loading-of-pcf-8563-to-hwclock.sh"
